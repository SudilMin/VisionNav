Commit message: voice actions and object position error fixed

File: wearable_sim/urdf/chest_rig.urdf (robot description, URDF)
Before this commit: robot blind_assist_wearable, 14 links, 13 joints
Links:
- link base_platform: mass 80.0 -> 1.0
